# Keil uVision project GD32E230K8U6_UWB.uvprojx, settings and files
target GD32E230K8U6_UWB (6160000::V6.16::ARMCLANG)
  device: GD32E230K8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M23") CLOCK(72000000) ESEL ELITTLE
  output: GD32E230K8U6_UWB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32E23x,GD32E230
  c misc: -Wno-c99-extensions -Wno-covered-switch-default -Wno-missing-noreturn -Wno-comment -Wno-padded
  c include: ..\..\Application\Inc;..\..\BSP\Inc;..\..\Drivers\UWB\Inc;..\..\Drivers\Log\Inc;..\..\Firmware\CMSIS\Core\Include;..\..\Firmware\CMSIS\GD32E23x\Include;..\..\Firmware\GD32E23x_standard_peripheral\Include
  asm define: GD32E23x,GD32E230
  asm include: ..\..\Firmware\CMSIS\Core\Include;..\..\Firmware\CMSIS\GD32E23x\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\GD32E230K8U6.sct
  group Application
    ../../Application/Src/: main.c gd32e23x_it.c
  group BSP
    ../../BSP/Src/: board.c
  group UWB Driver
    ../../Drivers/UWB/Src/: uwb_uart.c uwb_control.c
  group Log Driver
    ../../Drivers/Log/Src/: m_log.c
  group CMSIS
    ../../Firmware/CMSIS/GD32E23x/Source/: startup_gd32e23x.c system_gd32e23x.c
  group GD32E23x Peripheral Drivers
    ../../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_dma.c gd32e23x_exti.c gd32e23x_gpio.c gd32e23x_misc.c gd32e23x_rcu.c gd32e23x_syscfg.c gd32e23x_usart.c
